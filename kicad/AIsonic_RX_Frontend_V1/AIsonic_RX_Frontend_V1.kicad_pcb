# Repository zhaihuayun/supersonic

## KiCad design kicad/AIsonic_RX_Frontend_V1/AIsonic_RX_Frontend_V1.kicad_pcb

File kicad/README.md:

# AIsonic 探鱼器 V1 — KiCad 原理图 + PCB

根据 [`原理图/原理图.png`](../原理图/原理图.png) 设计的两块板，KiCad 9 工程：

| 工程 | 板尺寸 | 内容 |
|------|--------|------|
| [`AIsonic_TX_Driver_V1/`](./AIsonic_TX_Driver_V1/) | 100 × 70 mm，2 层 | TC4427 → IRL540N → EE19 1:8 变压器 → LC 匹配 → TX 换能器 |
| [`AIsonic_RX_Frontend_V1/`](./AIsonic_RX_Frontend_V1/) | 90 × 55 mm，2 层 | 限幅保护 → OPA320 LNA → 200 kHz MFB 带通 → AD8338 AGC → ADC 偏置输出 |

每个工程包含：

- `*.kicad_sch` 原理图（KiCad 当前的原理图格式；KiCad 9 已不再保存旧版 `.sch`）
- `*.kicad_pcb` 已布局、布线、双面 GND 铺铜和缝合过孔的 PCB
- `*.kicad_pro`（含网络类：电源 / 高压 / 栅极线宽与间距）
- `AIsonic.kicad_sym` / `AIsonic.pretty`：工程内自带的符号（OPA320、AD8338、EE19）和 EE19 封装
- `output/`：
  - 原理图 PDF/SVG、BOM（含立创编号 LCSC 列）
  - Gerber+钻孔压缩包、贴片坐标
  - PCB 正反面预览图、ERC/DRC 报告

## 验证结果

| 项 | TX | RX |
|----|----|----|
| ERC（原理图电气规则） | 0 错误 / 0 警告 | 0 错误 / 0 警告 |
| 网表与设计数据比对 | 一致 | 一致 |
| DRC 违规 | 0 | 0 |
| 未连接 | 0 | 0 |
| 原理图 ↔ PCB 一致性 | 0 差异 | 0 差异 |

## 相对原理图 PNG 的修正

1. **RX 带通滤波器**：PNG 的 3.3k / 2.2nF 中心频率约 22 kHz，不是 200 kHz。改为多反馈（MFB）带通：
   - 元件值：R5 = 2.4k，R6 = 143Ω，R7 = 4.7k，C3 = C4 = 1nF C0G
   - 结果：f0 ≈ 200 kHz，Q ≈ 3
2. **AD8338 引脚按 ADI 数据手册（LFCSP-16）**：
   - 单端输入：INPR 交流耦合，INMR 交流接地。
   - MODE 接 VBAT，DETO 接地。
   - VAGC 接内部 1.5V VREF；OFSN 经 100nF 接 VREF。
   - 增益由 J3（AGC_CTRL，接 MCU DAC）经 RC 滤波控制。
   - 裸焊盘 EP 接 GND，并打 4 个热过孔。
3. **TC4427 两路并联**：INA 和 INB 相连；OUTA、OUTB 各串 10Ω 后汇到 Q1 栅极，提高驱动电流。
4. **T1 次级引脚**：次级用 pin 10 → L1 → C3 → TX+，pin 6 → TX-（同名端仍为 1、6）。这样做是为了让高压走线不交叉。

## 下单前需人工确认

- **EE19 变压器封装** `AIsonic:EE19_5+5_Vertical`：按 5+5 针、针距 3.81 mm、排距 15.24 mm 估算，务必对照实际骨架尺寸修改。
- **AD8338 封装**：按 3×3 mm LFCSP-16、EP 1.6 mm 设计，核对立创 C578701 的实物封装。EP 上的热过孔建议选塞孔工艺。
- **L1（约 300 µH）/ C3（2.2nF 1kV）** 需按实际 PZT 电容调谐。
- BOM 中阻容的立创编号只是常用料，下单前核库存。

## 导入嘉立创EDA专业版

嘉立创EDA专业版 → 文件 → 导入 → KiCad，选择工程目录（或 `.kicad_sch` + `.kicad_pcb`）即可。也可以直接把 `output/*_gerber.zip` 上传到嘉立创下单。

## 重新生成

设计数据（元件、网络、原理图坐标、PCB 摆放）集中在 `_gen/design_tx.py`、`_gen/design_rx.py`。修改后重新生成：

```bash
# 依赖：KiCad 9（kicad-cli + pcbnew Python）、Java 17+、Freerouting 2.1
export FREEROUTING_JAR=/path/to/freerouting-2.1.0.jar
cd kicad/_gen
python3 build_pcb.py design_tx && python3 export.py design_tx
python3 build_pcb.py design_rx && python3 export.py design_rx
```

`build_pcb.py` 的执行步骤：

1. 生成原理图并跑 ERC，再比对网表。
2. 摆放元件，用 Freerouting 自动布线（结果不确定，最多重试 4 次）。
3. 铺铜、打缝合过孔，然后清理孤立过孔和悬空短线。
4. 最后运行 DRC（含原理图一致性检查）。

`--no-route` 只生成和摆放，不布线。

Parts:
C1, C2, C5, C6, C7, C9, C10, C12, C16: 100nF; C_0805_2012Metric; LCSC C14663
C3, C4: 1nF C0G; C_0805_2012Metric
C11, C14: 1uF; C_0805_2012Metric
C13: 10nF; C_0805_2012Metric
C15, C17: 10uF; C_0805_2012Metric
D1, D2: BAT54S; SOT-23; LCSC C727126
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: RX_PZT; TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal
J2: TO_MCU; TerminalBlock_Phoenix_MKDS-1-4-3.81_1x04_P3.81mm_Horizontal
J3: AGC_CTRL; TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal
J4: 3V3_IN; TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal
R1: 100Ω; R_0805_2012Metric
R2, R3: 100k; R_0805_2012Metric
R4, R9: 10k; R_0805_2012Metric
R5: 2.4k 1%; R_0805_2012Metric
R6: 143Ω 1%; R_0805_2012Metric
R7: 4.7k 1%; R_0805_2012Metric
R8: 1k; R_0805_2012Metric
R10, R11: 10k 1%; R_0805_2012Metric
U1, U2: OPA320AIDBVT; SOT-23-5; MPN OPA320AIDBVT; LCSC C206063
U3: AD8338ACPZ-R7; LFCSP-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm; MPN AD8338ACPZ-R7; LCSC C578701

Connections:
+3V3: C2.1, C5.1, C10.1, C11.1, C17.1, D2.2 (K), J2.3, J4.1, R10.1, U1.5 (V+), U2.5 (V+), U3.6 (MODE), U3.15 (VBAT)
/ADC_OUT: C14.2, J2.1, R9.1
/AGC_CTRL: J3.1, R8.1
/AGC_F: C13.1, R8.2, U3.7 (GAIN)
/BPF_INV: C4.2, R7.1, U2.4
/BPF_N: C3.1, C4.1, R5.2, R6.1
/BPF_OUT: C3.2, C6.1, R7.2, U2.1
/LNA_FB: R3.1, R4.1, U1.4
/LNA_IN: D2.3 (COM), R1.2, R2.1, U1.3
/LNA_OUT: R3.2, R5.1, U1.1
/OFSN_C: C9.1, U3.14 (OFSN)
/RX_AC: C1.2, R1.1
/RX_IN: C1.1, D1.3 (COM), J1.1
/VGA_INM: C7.2, U3.4 (INMR)
/VGA_INP: C6.2, U3.1 (INPR)
/VGA_OUT: C14.1, U3.11 (OUTP)
/VREF: C15.1, C16.1, J2.2, R2.2, R4.2, R6.2, R9.2, R10.2, R11.1, U2.3
/VREF15: C9.2, C12.1, U3.13 (VAGC), U3.16 (VREF)
GND: C2.2, C5.2, C7.1, C10.2, C11.2, C12.2, C13.2, C15.2, C16.2, C17.2, D1.1 (A), D1.2 (K), D2.1 (A), J1.2, J2.4, J3.2, J4.2, R11.2, U1.2 (V-), U2.2 (V-), U3.5 (COMM), U3.8 (DETO), U3.17 (EP)

Notes on the sheet:
RX接收板（200kHz 接收前端电路）
输入保护
LNA（OPA320，+20.8dB）
200kHz 带通（MFB，Q≈3）
AGC 可变增益 AD8338
ADC 驱动/偏置
虚拟地 VREF=1.65V
AGC 控制（STM32 DAC PA4）
VREF15 = AD8338 内部 1.5V 基准
RX 关键参数：
1. 输入信号：mV 级回波；D1 反并联钳位 ±0.3V，D2 将 LNA 输入钳在 GND~3V3
2. LNA：同相放大 G = 1 + R3/R4 = 11（+20.8dB），以 VREF=1.65V 为虚拟地
3. BPF：多路反馈带通，R5=2.4k / R6=143Ω / R7=4.7k / C3=C4=1nF C0G → f0≈200kHz，Q≈3（BW≈±34kHz），中心增益≈-1
4. AD8338：GAIN 0.1~1.1V 对应 0~80dB（12.5mV/dB），MODE=3V3 正斜率；DETO=GND、VAGC=VREF15 关闭内部 AGC
5. ADC 驱动：OUTP 经 C14 1uF 交流耦合，R9 10k 偏置到 1.65V → J2.1 → STM32H750 PA0（ADC1）
6. 时序：TX 发送 20 周期后等待 300us 再启动 ADC DMA（2048 点），然后 FFT / 峰值检测 / 距离计算

Board: 2 copper layers, 90.0 x 55.0 mm, 40 parts (0 on the bottom side), 19 nets.

File kicad/AIsonic_RX_Frontend_V1/output/AIsonic_RX_Frontend_V1_BOM.csv:

"Designator","Value","Footprint","LCSC","MPN","Quantity"
"C1,C2,C5-C7,C9,C10,C12,C16","100nF","Capacitor_SMD:C_0805_2012Metric","C14663","","9"
"C3,C4","1nF C0G","Capacitor_SMD:C_0805_2012Metric","","","2"
"C11,C14","1uF","Capacitor_SMD:C_0805_2012Metric","","","2"
"C13","10nF","Capacitor_SMD:C_0805_2012Metric","","","1"
"C15,C17","10uF","Capacitor_SMD:C_0805_2012Metric","","","2"
"D1,D2","BAT54S","Package_TO_SOT_SMD:SOT-23","C727126","","2"
"J1","RX_PZT","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal","","","1"
"J2","TO_MCU","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1-4-3.81_1x04_P3.81mm_Horizontal","","","1"
"J3","AGC_CTRL","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal","","","1"
"J4","3V3_IN","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal","","","1"
"R1","100Ω","Resistor_SMD:R_0805_2012Metric","","","1"
"R2,R3","100k","Resistor_SMD:R_0805_2012Metric","","","2"
"R4,R9","10k","Resistor_SMD:R_0805_2012Metric","","","2"
"R5","2.4k 1%","Resistor_SMD:R_0805_2012Metric","","","1"
"R6","143Ω 1%","Resistor_SMD:R_0805_2012Metric","","","1"
"R7","4.7k 1%","Resistor_SMD:R_0805_2012Metric","","","1"
"R8","1k","Resistor_SMD:R_0805_2012Metric","","","1"
"R10,R11","10k 1%","Resistor_SMD:R_0805_2012Metric","","","2"
"U1,U2","OPA320AIDBVT","Package_TO_SOT_SMD:SOT-23-5","C206063","OPA320AIDBVT","2"
"U3","AD8338ACPZ-R7","Package_CSP:LFCSP-16-1EP_3x3mm_P0.5mm_EP1.6x1.6mm","C578701","AD8338ACPZ-R7","1"

## KiCad design kicad/AIsonic_TX_Driver_V1/AIsonic_TX_Driver_V1.kicad_pcb

Parts:
C1: 100nF 50V; C_0805_2012Metric; LCSC C14663
C2: 10uF 25V; C_1206_3216Metric
C3: 2.2nF 1kV; C_Disc_D7.5mm_W5.0mm_P7.50mm
C5: 100uF 25V; CP_Radial_D8.0mm_P3.50mm
D1: SMBJ100A; D_SMB; LCSC C151249
H1, H2, H3, H4: M3; MountingHole_3.2mm_M3
J1: PWM_IN; TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal
J2: +12V_IN; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
J3: TX_PZT; TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizont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
L1: 300uH; L_Radial_D10.0mm_P5.00mm_Fastron_07M
Q1: IRL540N; TO-220-3_Vertical; MPN IRL540NPBF; LCSC C5240567
R1, R2, R4: 10Ω; R_0805_2012Metric
R3, R5: 10k; R_0805_2012Metric
T1: EE19 1:8 (10T:80T); EE19_5+5_Vertical
U1: TC4427AEOA; SOIC-8_3.9x4.9mm_P1.27mm; MPN TC4427AEOA713; LCSC C20551

Connections:
+12V: C1.1, C2.1, C5.1, J2.1, T1.1, U1.6 (V_{DD})
/DRAIN: D1.1 (K), Q1.2 (D), T1.3 (P2)
/DRV_IN: R1.2, R5.1, U1.2 (IN_A), U1.4 (IN_B)
/GATE: Q1.1 (G), R2.2, R3.1, R4.2
/GATE_A: R2.1, U1.7 (OUT_A)
/GATE_B: R4.1, U1.5 (OUT_B)
/LC_MID: C3.1, L1.2
/PWM_IN: J1.1, R1.1
/SEC_HI: L1.1, T1.10 (S2)
/TX+: C3.2, J3.1
/TX-: J3.2, T1.6 (S1)
GND: C1.2, C2.2, C5.2, D1.2 (A), J1.2, J2.2, Q1.3 (S), R3.2, R5.2, U1.3 (GND)

Notes on the sheet:
TX发射板（200kHz 发射驱动电路）
栅极驱动 TC4427
功率 MOS / TVS
变压器 EE19 1:8
LC 匹配（200kHz）
供电接口 +12V
TX 关键参数：
1. 发射频率 200kHz（PWM 50%，STM32H750 PA8）
2. 发射脉冲 20 周期（100us），禁止连续发射
3. 次级驱动电压 80~150Vpp
4. 变压器 1:8（10T:80T），同名端 T1.1 / T1.6
5. 匹配 L1=300uH、C3=2.2nF/1kV（按 PZT 实测微调）
6. TC4427 双通道并联：INA=INB，OUTA/OUTB 各串 10Ω 到栅极
7. PCB：C5-T1-Q1-GND 功率回路最短；次级/LC/J3 高压区间距 ≥1mm

Board: 2 copper layers, 100.0 x 70.0 mm, 21 parts (0 on the bottom side), 12 nets.

File kicad/AIsonic_TX_Driver_V1/output/AIsonic_TX_Driver_V1_BOM.csv:

"Designator","Value","Footprint","LCSC","MPN","Quantity"
"C1","100nF 50V","Capacitor_SMD:C_0805_2012Metric","C14663","","1"
"C2","10uF 25V","Capacitor_SMD:C_1206_3216Metric","","","1"
"C3","2.2nF 1kV","Capacitor_THT:C_Disc_D7.5mm_W5.0mm_P7.50mm","","","1"
"C5","100uF 25V","Capacitor_THT:CP_Radial_D8.0mm_P3.50mm","","","1"
"D1","SMBJ100A","Diode_SMD:D_SMB","C151249","","1"
"J1","PWM_IN","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1-2-3.81_1x02_P3.81mm_Horizontal","","","1"
"J2","+12V_IN","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal","","","1"
"J3","TX_PZT","TerminalBlock_Phoenix:TerminalBlock_Phoenix_MKDS-1,5-2-5.08_1x02_P5.08mm_Horizontal","","","1"
"L1","300uH","Inductor_THT:L_Radial_D10.0mm_P5.00mm_Fastron_07M","","","1"
"Q1","IRL540N","Package_TO_SOT_THT:TO-220-3_Vertical","C5240567","IRL540NPBF","1"
"R1,R2,R4","10Ω","Resistor_SMD:R_0805_2012Metric","","","3"
"R3,R5","10k","Resistor_SMD:R_0805_2012Metric","","","2"
"T1","EE19 1:8 (10T:80T)","AIsonic:EE19_5+5_Vertical","","","1"
"U1","TC4427AEOA","Package_SO:SOIC-8_3.9x4.9mm_P1.27mm","C20551","TC4427AEOA713","1"
